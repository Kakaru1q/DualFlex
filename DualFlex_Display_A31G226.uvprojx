# Keil uVision project DualFlex_Display_A31G226.uvprojx, settings and files
target DualFlex (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: DualFlex_Display_A31G226 +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Device\ABOV\A31G22x\Include;.\CMSIS\Include;.\Drivers\Include;.\Src;.\Header
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Src/: Main.c Init.c LEDControl.c Isr.c GlobalValue.c Touch.c Uart.c Display.c
  group Device
    ./Device/ABOV/A31G22x/Source/ARM/: startup_A31G22x.s
    ./Device/ABOV/A31G22x/Source/: system_A31G22x.c
  group Header
    ./Device/ABOV/A31G22x/Include/: A31G22x.h system_A31G22x.h
    ./Header/: Init.h LEDControl.h GlobalValue.h typedefine.h Touch.h Uart.h Display.h
  group Driver
    ./Drivers/Source/: A31G22x_hal_scu.c A31G22x_hal_i2c.c A31G22x_hal_uartn.c debug.c debug_cmd.c debug_frmwrk.c A31G22x_hal_pcu.c A31G22x_hal_cfmc.c A31G22x_hal_timer1n.c
